# Keil uVision project testhsusb.uvprojx, settings and files
target testhsusb (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.6.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(12000000) FPU3(SFPU) ELITTLE CPUTYPE("Cortex-M7")
  output: testhsusb
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F7xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal.c stm32f7xx_hal_dma.c stm32f7xx_hal_tim.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc_ex.c
  group Application/User
    ../Src/: stm32f7xx_it.c main.c usbd_conf.c usb_device.c usbd_desc.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_TIM.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
software components: CMSIS:CORE 4.1.0
